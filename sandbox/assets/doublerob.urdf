Commit message: 2d example working

File: sandbox/assets/doublerob.urdf (robot description, URDF)
Before this commit: robot planar2dof_robot, 7 links, 6 joints
Links:
- link linka: geometry collision box size=0.1 0.1 1.1; visual box size=0.1 0.1 1.1
